# Repository osbock/mousy

## KiCad design Mousy_anool_v1/Mousy.kicad_pcb

Parts:
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: Mouse_out; CONN_PLUG_A_DS_09_A_KG_T2S
J2: Mouse_in; CONN_SOCKET_A-DF_09_A_KG-T4S
Logo1: Mouse-; Mouse+
U1: 74LS125; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
/BUTTON: J1.7, J2.7
/MOUSE_ID: J1.1, J2.1
/XDIR_IN: J2.4, U1.5
/XDIR_OUT: J1.4, U1.6
/XMOVE_IN: J2.5, U1.12
/XMOVE_OUT: J1.5, U1.11
/YDIR_IN: J2.8, U1.2
/YDIR_OUT: J1.8, U1.3
/YMOVE_IN: J2.9, U1.9
/YMOVE_OUT: J1.9, U1.8
GND: C1.2, J1.3, J2.3, U1.1, U1.4, U1.7 (GND), U1.10, U1.13
VCC: C1.1, J1.2, J2.2, U1.14 (VCC)

Board: 2 copper layers, 31.8 x 47.0 mm, 5 parts (1 on the bottom side), 12 nets.

## Commit log

2023-04-21 add mouse, fix some gnd nets
2023-04-21 2 new versions
2023-04-21 renamed folders since Kicad expects folder and project names to be identical
2023-04-21 added CAD models in fabricate folder
